# Keil uVision project stm32f1-contiki.uvproj, settings and files
target stm32f1-contiki (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f1-contiki
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\contiki\core;..\contiki;..\contiki\portable;..\cpu\inc;..\cpu
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.c
  group contiki
    ../contiki/core/sys/: etimer.c process.c timer.c autostart.c
  group portable
    ../contiki/portable/: clock.c
  group cpu
    ../cpu/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
    ../cpu/src/: stm32f10x_rcc.c
